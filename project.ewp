# IAR project project.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-arch4-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m4809 ATmega4809
  ICCAVR.CCDefines: __mega4809__; F_CPU=3333333
  ICCAVR.newCCIncludePaths: config; include; utils; utils\assembler; freeRTOS\portable\MemMang; OLED; freeRTOS\portable\GCC\ATmega4809; freeRTOS\include; ; freeRTOS\portable\IAR\ATmega4809
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  AAVR.ADefines: __mega4809__
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm4809.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; __mega4809__; F_CPU=3333333
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: atmel_start.c atmel_start.h driver_isr.c FreeRTOSConfig.h main.c
  group src/config
    config/: clock_config.h
  group src/freeRTOS
    freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group src/freeRTOS/include
    freeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group src/freeRTOS/portable/IAR/ATmega4809
    freeRTOS/portable/IAR/ATmega4809/: port.c portmacro.h portmacro.s90
  group src/freeRTOS/portable/MemMang
    freeRTOS/portable/MemMang/: heap.c heap_1.h heap_2.h heap_3.h heap_4.h heap_5.h
  group src/include
    include/: atmel_start_pins.h bod.h ccp.h clkctrl.h cpuint.h driver_init.h port.h protected_io.h rstctrl.h slpctrl.h system.h
  group src/src
    src/: bod.c clkctrl.c cpuint.c driver_init.c protected_io.S slpctrl.c
  group src/utils
    utils/: assembler.h atomic.h compiler.h interrupt_avr8.h utils.h utils_assert.h
  group src/utils/assembler
    utils/assembler/: gas.h iar.h
